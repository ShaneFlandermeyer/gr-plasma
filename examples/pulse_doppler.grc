options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: n_pulse_cpi
  id: variable
  parameters:
    value: '512'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {state: disabled}
- name: plasma_cw_to_pulsed_0
  id: plasma_cw_to_pulsed
  parameters:
    prf: 5e3
    prf_key: radar:prf
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
  states: {}
- name: plasma_lfm_source_0
  id: plasma_lfm_source
  parameters:
    bandwidth: samp_rate/2
    bandwidth_key: radar:bandwidth
    duration_key: radar:duration
    label_key: core:label
    prf: '0'
    prf_key: radar:prf
    pulse_width: '10e-6'
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
    start_freq: '-samp_rate/4'
    start_freq_key: radar:start_freq
  states: {}
- name: plasma_pulse_doppler_0
  id: plasma_pulse_doppler
  parameters:
    backend: plasma.Device.CUDA
    depth: '100'
    doppler_fft_size_key: doppler_fft_size
    n_pulse_cpi: n_pulse_cpi
    nfft: n_pulse_cpi
  states: {}
- name: plasma_pulse_to_cpi_0
  id: plasma_pulse_to_cpi
  parameters:
    n_pulse_cpi: n_pulse_cpi
    n_pulse_cpi_key: radar:n_pulse_cpi
  states: {}
- name: plasma_range_doppler_sink_0
  id: plasma_range_doppler_sink
  parameters:
    center_freq: 5e9
    center_freq_key: core:tx_freq
    depth: '10'
    detection_indices_key: detection_indices
    dynamic_range: '60'
    dynamic_range_key: dynamic_range
    n_matrix_col_key: n_matrix_col
    nrow: n_pulse_cpi
    prf_key: radar:prf
    pulsewidth_key: radar:duration
    samp_rate: samp_rate
    samp_rate_key: core:sample_rate
  states: {}
- name: plasma_usrp_radar_0
  id: plasma_usrp_radar
  parameters:
    args: '"addr=192.168.30.2, use_dpdk=1"'
    cal_file: '"/home/shane/.uhd/delay.json"'
    elevate_priority: 'True'
    rx_freq: 5e9
    rx_freq_key: core:rx_freq
    rx_gain: '20'
    samp_rate: samp_rate
    sample_start_key: core:sample_start
    start_delay: '0.1'
    tx_freq: 5e9
    tx_freq_key: core:tx_freq
    tx_gain: '10'
    verbose: 'False'
  states: {}

connections:
- [plasma_cw_to_pulsed_0, out, plasma_usrp_radar_0, in]
- [plasma_lfm_source_0, out, plasma_cw_to_pulsed_0, in]
- [plasma_lfm_source_0, out, plasma_pulse_doppler_0, tx]
- [plasma_pulse_doppler_0, out, blocks_message_debug_0, print]
- [plasma_pulse_doppler_0, out, plasma_range_doppler_sink_0, in]
- [plasma_pulse_to_cpi_0, out, plasma_pulse_doppler_0, rx]
- [plasma_usrp_radar_0, out, plasma_pulse_to_cpi_0, in]

metadata:
  file_format: 1
