options:
  parameters:
    author: Shane Flandermeyer
    description: Example of range and doppler processing
    generate_options: qt_gui
    id: pulse_doppler
    output_language: python
    title: Pulse Doppler Processing
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 0.5*samp_rate
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 5e9
  states: {}
- name: num_pulse_cpi
  id: variable
  parameters:
    value: '512'
  states: {}
- name: prf
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40e6
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}
- name: plasma_cw_to_pulsed_0
  id: plasma_cw_to_pulsed
  parameters:
    prf: 10e3
    prf_key: radar:prf
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
  states: {}
- name: plasma_lfm_source_1_0
  id: plasma_lfm_source
  parameters:
    bandwidth: bandwidth
    bandwidth_key: radar:bandwidth
    duration_key: radar:duration
    label_key: core:label
    prf: '0'
    prf_key: radar:prf
    pulse_width: '10e-6'
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
    start_freq: '-bandwidth/2'
    start_freq_key: radar:start_freq
  states: {}
- name: plasma_match_filt_0
  id: plasma_match_filt
  parameters:
    backend: plasma.Device.CPU
    depth: '100'
    n_pulse_cpi_key: n_pulse_cpi
    num_pulse_cpi: '1'
  states: {state: disabled}
- name: plasma_usrp_radar_0
  id: plasma_usrp_radar
  parameters:
    args: '"num_send_frames=512,num_recv_frames=512"'
    cal_file: /home/shane/.uhd/delay_calibration.json
    center_freq_key: core:frequency
    rx_freq: center_freq
    rx_gain: '40'
    rx_priority: '0.0'
    samp_rate: samp_rate
    sample_start_key: core:sample_start
    start_time: '0.2'
    tx_freq: center_freq
    tx_gain: '50'
    tx_priority: '0.0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    srate: samp_rate
    type: msg_complex
  states: {}

connections:
- [plasma_cw_to_pulsed_0, out, plasma_usrp_radar_0, in]
- [plasma_lfm_source_1_0, out, plasma_cw_to_pulsed_0, in]
- [plasma_match_filt_0, out, qtgui_time_sink_x_0, in]
- [plasma_usrp_radar_0, out, qtgui_time_sink_x_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.3.0
