options:
  parameters:
    author: Shane Flandermeyer
    description: Example of range and doppler processing
    generate_options: qt_gui
    id: pulse_doppler
    output_language: python
    title: Pulse Doppler Processing
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 5e9
  states: {}
- name: num_pulse_cpi
  id: variable
  parameters:
    value: '512'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 50e6
  states: {}
- name: plasma_doppler_processing_0
  id: plasma_doppler_processing
  parameters:
    depth: '1'
    nfft: num_pulse_cpi
    num_pulse_cpi: num_pulse_cpi
  states: {}
- name: plasma_lfm_source_0
  id: plasma_lfm_source
  parameters:
    bandwidth: 0.8*samp_rate
    pulse_width: '20e-6'
    samp_rate: samp_rate
  states: {}
- name: plasma_match_filt_0
  id: plasma_match_filt
  parameters:
    depth: '1'
    device: plasma.match_filt.CPU
    num_pulse_cpi: num_pulse_cpi
  states: {}
- name: plasma_pdu_file_sink_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/shane/gpu.dat
    meta_filename: ''
    save_meta: 'False'
    type: complex
  states: {}
- name: plasma_pulse_to_cpi_0
  id: plasma_pulse_to_cpi
  parameters:
    num_pulse_cpi: num_pulse_cpi
  states: {}
- name: plasma_range_doppler_sink_0
  id: plasma_range_doppler_sink
  parameters:
    center_freq: center_freq
    depth: '1'
    dynamic_range: '80'
    num_pulse_cpi: num_pulse_cpi
    samp_rate: samp_rate
  states: {}
- name: plasma_usrp_radar_0
  id: plasma_usrp_radar
  parameters:
    args: num_send_frames=512,num_recv_frames=512
    cal_file: '"/home/shane/.uhd/delay_calibration.json"'
    rx_freq: center_freq
    rx_gain: '50'
    rx_priority: '1.0'
    samp_rate: samp_rate
    start_time: '0.2'
    tx_freq: center_freq
    tx_gain: '50'
    tx_priority: '1.0'
  states: {}
- name: plasma_waveform_controller_0
  id: plasma_waveform_controller
  parameters:
    prf: '10000'
    samp_rate: samp_rate
  states: {}

connections:
- [plasma_doppler_processing_0, out, plasma_pdu_file_sink_0, in]
- [plasma_doppler_processing_0, out, plasma_range_doppler_sink_0, in]
- [plasma_lfm_source_0, pdu, plasma_match_filt_0, tx]
- [plasma_lfm_source_0, pdu, plasma_waveform_controller_0, in]
- [plasma_match_filt_0, out, plasma_doppler_processing_0, in]
- [plasma_pulse_to_cpi_0, out, plasma_match_filt_0, rx]
- [plasma_usrp_radar_0, out, plasma_pulse_to_cpi_0, in]
- [plasma_waveform_controller_0, out, plasma_usrp_radar_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.3.0
