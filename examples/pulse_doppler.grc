options:
  parameters:
    author: Shane Flandermeyer
    description: Example of range and doppler processing
    generate_options: qt_gui
    id: pulse_doppler
    output_language: python
    title: Pulse Doppler Processing
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 0.75*samp_rate
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 2.45e9
  states: {}
- name: n_pulse_cpi
  id: variable
  parameters:
    value: '512'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40e6
  states: {}
- name: plasma_cfar2D_0
  id: plasma_cfar2D
  parameters:
    backend: plasma.Device.DEFAULT
    depth: '1'
    detection_indices_key: detection_indices
    guard_win_size: (2,2)
    n_detections_key: n_detections
    n_pulse_cpi_key: n_pulse_cpi
    num_pulse_cpi: n_pulse_cpi
    pfa: '1e-6'
    train_win_size: (3,3)
  states: {state: bypassed}
- name: plasma_doppler_processing_0
  id: plasma_doppler_processing
  parameters:
    backend: plasma.Device.DEFAULT
    depth: '1'
    doppler_fft_size: doppler_fft_size
    n_pulse_cpi_key: n_pulse_cpi
    nfft: n_pulse_cpi
    num_pulse_cpi: n_pulse_cpi
  states: {}
- name: plasma_lfm_source_0
  id: plasma_lfm_source
  parameters:
    bandwidth: 0.8*samp_rate
    bandwidth_key: radar:bandwidth
    duration_key: radar:duration
    label_key: core:label
    pulse_width: '20e-6'
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
    start_freq: '-bandwidth/2'
    start_freq_key: radar:start_freq
  states: {}
- name: plasma_match_filt_0
  id: plasma_match_filt
  parameters:
    backend: plasma.Device.DEFAULT
    depth: '1'
    n_pulse_cpi_key: n_pulse_cpi
    num_pulse_cpi: n_pulse_cpi
  states: {}
- name: plasma_pdu_file_sink_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: ''
    meta_filename: ''
    save_meta: 'False'
    type: complex
  states: {state: disabled}
- name: plasma_pulse_to_cpi_0
  id: plasma_pulse_to_cpi
  parameters:
    n_pulse_cpi: n_pulse_cpi
    n_pulse_cpi_key: radar:n_pulse_cpi
  states: {}
- name: plasma_range_doppler_sink_0
  id: plasma_range_doppler_sink
  parameters:
    center_freq: center_freq
    center_freq_key: core:frequency
    depth: '1'
    detection_indices_key: detection_indices
    dynamic_range: '80'
    dynamic_range_key: dynamic_range
    n_matrix_col_key: n_matrix_col
    nrow: n_pulse_cpi
    prf_key: radar:prf
    pulsewidth_key: radar:duration
    samp_rate: samp_rate
    samp_rate_key: core:sample_rate
  states: {}
- name: plasma_usrp_radar_0
  id: plasma_usrp_radar
  parameters:
    args: num_send_frames=512,num_recv_frames=512
    cal_file: '"/home/shane/.uhd/delay_calibration.json"'
    center_freq_key: core:frequency
    prf_key: radar:prf
    rx_freq: center_freq
    rx_gain: '50'
    rx_priority: '1.0'
    samp_rate: samp_rate
    sample_start_key: core:sample_start
    start_time: '0.2'
    tx_freq: center_freq
    tx_gain: '50'
    tx_priority: '1.0'
  states: {}
- name: plasma_waveform_controller_0
  id: plasma_waveform_controller
  parameters:
    prf: '10000'
    prf_key: radar:prf
    samp_rate: samp_rate
    samp_rate_key: core:sample_rate
  states: {}

connections:
- [plasma_cfar2D_0, out, plasma_pdu_file_sink_0, in]
- [plasma_cfar2D_0, out, plasma_range_doppler_sink_0, in]
- [plasma_doppler_processing_0, out, plasma_cfar2D_0, in]
- [plasma_lfm_source_0, out, plasma_match_filt_0, tx]
- [plasma_lfm_source_0, out, plasma_waveform_controller_0, in]
- [plasma_match_filt_0, out, plasma_doppler_processing_0, in]
- [plasma_pulse_to_cpi_0, out, plasma_match_filt_0, rx]
- [plasma_usrp_radar_0, out, plasma_pulse_to_cpi_0, in]
- [plasma_waveform_controller_0, out, plasma_usrp_radar_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.3.0
